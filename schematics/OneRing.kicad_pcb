# Repository Sc222/smart-ring-system

File README.md:

# Smart Ring
Smart Ring - система для управления умным домом, которая состоит из 3-х частей:
- Носимое устройство
- Мобильное приложение
- Сервер

## Демо
- [Видео с примером интерфейса приложения и работы всей системы (здесь еще не само устройство, а отладочная плата)](https://drive.google.com/file/d/1LhwEsBvcHT-mtzOmQIQSLOzcvDy6nwD8/view?usp=sharing)
- [Презентация (более подробная информация в заметках докладчика)](https://docs.google.com/presentation/d/179yZ5rh-BqtIIjekmeVIYNVyHlKF2Y8zf11Fv1ZyADk/edit?usp=sharing)

## Носимое устройство
##### Описание
Устройство представляет собой кольцо из Bluetooth модуля, кнопки, батареи и зарядки. При нажатии на кнопку, сигнал передается по Bluetooth на смартфон. Такой принцип позволяет включать устройство только при нажатии на кнопку, что снижает энергопотребление и позволяет перезаряжать девайс как можно реже.
##### Исходные файлы
- [Прошивка](https://github.com/Sc222/SmartRingApp/tree/master/device/examples/ble_peripheral/smart_ring_ble)
- [Схемотехника](https://github.com/Sc222/SmartRingApp/tree/master/schematics)

##### Установка
Для компиляции прошивки требуется установить [nRF5 SDK 15.0.0](https://www.nordicsemi.com/Software-and-tools/Software/nRF5-SDK/Download#infotabs) в папку [/device](https://github.com/Sc222/SmartRingApp/tree/master/device).
## Мобильное приложение
##### Описание
Мобильное приложение используется для настройки устройства, обработки нажатий на его кнопку и отправки данных на сервер.
Приложение состоит из 3 основных разделов:
- Раздел настройки устройства
- Раздел настройки команд
- Раздел настройки локаций

При считывании данных с устройства, приложение определяет текущую локацию пользователя и на основании полученных данных формирует событие, отправляемое на сервер.
##### Исходные файлы
- [Android](https://github.com/Sc222/SmartRingApp/tree/master/application)

##### Зависимости
- **Для интерфейса:**
  - 'com.google.android.gms:play-services-maps:16.1.0'
  - 'androidx.appcompat:appcompat:1.1.0'
  - 'androidx.transition:transition:1.3.1'
  - 'com.google.android.material:material:1.1.0'
  - 'androidx.constraintlayout:constraintlayout:1.1.3'
  - 'androidx.vectordrawable:vectordrawable:1.1.0'
  - 'androidx.navigation:navigation-fragment:2.2.2'
  - 'androidx.navigation:navigation-ui:2.2.2'
  - 'androidx.recyclerview:recyclerview:1.1.0'
- **Для работы с Bluetooth:**
  - 'no.nordicsemi.android.support.v18:scanner:1.4.3'
  - 'no.nordicsemi.android:ble-livedata:2.2.0'
  - 'no.nordicsemi.android:log:2.2.0'
- **Для работы с базой данных:**
  - 'androidx.room:room-runtime:2.2.5'
  - 'androidx.room:room-compiler:2.2.5'
- **Для http запросов:**
  - 'com.android.volley:volley:1.1.1'
- **Остальные:**
  - 'androidx.lifecycle:lifecycle-extensions:2.2.0'
  - 'androidx.preference:preference:1.1.1'
  - 'androidx.legacy:legacy-support-v4:1.0.0'

## Cервер
##### Описание
Сервер используется для интеграции устройства с какой-либо системой управления умным домом (на данный момент реализована интеграция со SmartThings).  
Сервер получает обновления состояния кнопки от мобильного приложения и отсылает их в систему SmartThings.
##### Исходные файлы
- [Сервер](https://github.com/Sc222/SmartRingApp/tree/master/server)

##### Установка
На данный момент система использует сервер, который запущен на [glitch](https://glitch.com/edit/#!/smart-ring-webhook?path=index.js%3A301%3A0).  
Для запуска сервера локально выполните:
```sh
$ cd server
$ npm install
$ node start
```
## Что не работает / требует улучшений
### Устройство
- На данный момент не реализованы двойные, тройные, длинные и другие нажатия, вместо этого отладочная плата просто обрабатывает нажатия на 4 разные кнопки.
### Мобильное приложение
- Раздел "устройства" не функционирует полностью, интерфейс реализован, но не передает настройки устройству
- Требуется выполнить рефакторинг сервиса и возможно его требуется разделить на 2 отдельных (Location и Ble Service)
- Требуется оптимизировать сканирование устройств и настроить фильтры, чтобы снизить энергопотребление
- Некоторые списки реализованы не через RecyclerAdapter'ы, нужно это исправить
- Сделать внедрение зависимостей через Dagger
### Сервер
 - Заменить Mock-авторизацию на настоящую
 - При перезапуске сервера слетает ```accessToken``` и устройство требуется передобавлять. Для исправления такой проблемы стоит написать метод, позволяющий перезапрашивать токены и загрузить сервер на более удобный хостинг.
 - Требуется добавить базу данных (или хотя бы текстовый файл) для хранения текущего состояния кнопки
 - На данный момент реализована поддержка одного устройства. Нужно сделать поддержку нескольких и придумать, как генерировать ```externalDeviceId``` на основании локации и комнаты, в которой будет работать устройство

## KiCad design schematics/OneRing.kicad_pcb

Parts:
AE1: 2.4 GHz; BLE_ARCH_1MM; Part Number 2450AT18A100E
BT1: 30 mAh; lipol_10x10
C1: 3.3n; C_0402_1005Metric
C2, C4, C6, C9, C13: 0.1u; C_0402_1005Metric
C3: N.C.; C_0402_1005Metric
C5, C11, C14, C15: 1u; C_0603_1608Metric
C7, C8: 10p; C_0402_1005Metric
C10: 4.7u; C_0603_1608Metric
C12: 0.8p; C_0402_1005Metric
D1, D2: NSR05F30NXT5G; D_0402_1005Metric
D3: GREEN; LED_0402_1005Metric
J1: Charger; pogo_2x_in
J2: L+; Pin_D1.0mm_L10.0mm_LooseFit
J3: L-; Pin_D1.0mm_L10.0mm_LooseFit
L1: 7.2u; Part Number 760308101220
L2: 3.9u; L_0402_1005Metric
R1, R3, R5, R6: 100k; R_0402_1005Metric
R2: 1M; R_0402_1005Metric
R4: 560; R_0402_1005Metric
SW1: Button; IT-1188E
TP1: VDD; TestPoint_Pad_D1.0mm
TP2: SWDIO; TestPoint_Pad_D1.0mm
TP3: SWDCLK; TestPoint_Pad_D1.0mm
TP4: RESET; TestPoint_Pad_D1.0mm
TP5: LOGGER; TestPoint_Pad_D1.0mm
TP6: GND; TestPoint_Pad_D1.0mm
U1: nRF52832-QFxx; QFN-48-1EP_6x6mm_P0.4mm_EP4.6x4.6mm
U2: LTC4124; LQFN12
U3: TPS22929D; SOT-23-6
U4: NCP170AXV330T2G; SOT-563
Y1: 32 MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm; Part Number NX2520SA

Connections:
+3V3: C6.1, C9.1, C10.1, C15.2, R4.2, U1.13 (VDD), U1.36 (VDD), U1.48 (VDD), U4.3 (OUT)
+BATT: BT1.1 (+), U2.10 (BAT)
/NRF_ANT: L2.2, U1.30 (ANT)
/NRF_BAT_LVL: R5.2, R6.1, U1.4 (P0.02/AIN0)
/NRF_BTN: C13.1, R3.1, U1.6 (P0.04/AIN2)
/NRF_DEC1: C2.1, U1.1 (DEC1)
/NRF_DEC2: C3.1, U1.32 (DEC2)
/NRF_DEC3: C4.1, U1.33 (DEC3)
/NRF_DEC4: C5.1, U1.46 (DEC4), U1.47 (DCC)
/NRF_LED: D3.1 (K), U1.7 (P0.05/AIN3)
/NRF_PWR: R1.2, U1.5 (P0.03/AIN1), U3.3 (ON)
/NRF_RESET: TP2.1, U1.24 (P0.21/~RESET)
/NRF_SWDCLK: TP3.1, U1.25 (SWDCLK)
/NRF_SWDIO: TP4.1, U1.26 (SWDIO)
/NRF_SWO: TP5.1, U1.21 (P0.18/SWO)
/NRF_XC_N: C8.2, U1.35 (XC2), Y1.3
/NRF_XC_P: C7.2, U1.34 (XC1), Y1.1
/VDC_IN: D1.2 (A), J1.1
/V_BAT_PROT: C14.2, D2.1 (K), R5.1, U3.1 (VOUT), U4.1 (IN), U4.6 (EN)
GND: AE1.2 (PCB_Trace), BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.1, C12.2, C13.2, C14.1, C15.1, J1.2, J3.1, R1.1, R2.2, R6.2, SW1.3 (L), SW1.4 (L), TP6.1, U1.31 (VSS), U1.45 (VSS), U1.49 (VSS), U2.5 (VSEL2), U2.6 (ISEL1), U2.7 (ISEL2), U2.13 (GND), U3.2 (GND), U3.5 (GND), U4.2 (GND), U4.5 (GND), Y1.2, Y1.4
unnamed: AE1.1 (FEED), C12.1, L2.1
unnamed: D2.2 (A), R2.1, R3.2, SW1.2
unnamed: D3.2 (A), R4.1
VAA: C1.1, J2.1, U2.11 (ACIN)
VDC: D1.1 (K), U2.12 (DCIN)
VDD: C11.2, SW1.1, TP1.1, U2.1 (VCC), U2.3 (PRECHG), U2.4 (VSEL1), U2.8 (LBSEL), U2.9 (NTC), U3.4 (VIN), U3.6 (VIN)

Notes on the sheet:
programmer
4.2V (VSEL1 = 1, VSEL2 = 0) 10 mA (ISEL1 = 0, ISEL2 = 0) 3.2V disconnect (LBSEL = 1)
VDD 13
VDD 36
VDD 48

Board: 4 copper layers, 21.0 x 26.0 mm, 42 parts (0 on the bottom side), 26 nets.

## KiCad design schematics/schematics.kicad_pcb

Parts:
BT1: +4.2V; PinHeader_1x02_P1.00mm_Horizontal
C1: sm; C_0402_1005Metric
C2, C3: 12pF; C_0402_1005Metric
C4: 0.8pF; C_0402_1005Metric
C5: 100pF; C_0402_1005Metric
C6: N.C.; C_0402_1005Metric
C7, C9: 100nF; C_0402_1005Metric
C8: 1.0μF; C_0402_1005Metric
C10: 1u; C_0402_1005Metric
C11, C12: 0.1u; C_0402_1005Metric
D1: MCL4148; D_MicroMELF
D2: LED_Indicator; LED_0402_1005Metric
L1: sm; L_TDK_SLF6025
L2: 3.9nH; L_0402_1005Metric
R1: 1M; R_0402_1005Metric
R2: 100k; R_0402_1005Metric
R3: 220; R_0402_1005Metric
SW1: Button; SW_DIP_SPSTx02_Slide_6.7x6.64mm_W6.73mm_P2.54mm_LowProfile_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
U1: LTC4124; QFN-12-1EP_3x3mm_P0.5mm_EP1.65x1.65mm
U2: nRF52832-QFxx; QFN-48-1EP_6x6mm_P0.4mm_EP4.6x4.6mm
U3: TPS22929D; SOT-23-6
Y1: 32mHz; Crystal_SMD_2012-2Pin_2.0x1.2mm

Connections:
/MCU_BTN: C11.2, R2.1, U2.4 (P0.02/AIN0)
/MCU_PWR: U2.8 (P0.06), U3.3
/RF: L2.1
/V_LIPOL: C10.1, SW1.1 (A), U1.1, U1.2, U1.3, U1.4, U3.4, U3.6
/V_SUP: C9.2, C12.1, D1.1 (K), U2.13 (VDD), U2.36 (VDD), U2.48 (VDD), U3.1
GND: BT1.2, C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.1, C12.2, D2.1 (K), L1.1, R1.2, U1.5, U1.6, U1.7, U1.8, U1.9, U1.12, U1.13, U2.31 (VSS), U2.45 (VSS), U2.49 (VSS), U3.2, U3.5
unnamed: BT1.1, U1.10
unnamed: C1.1, L1.2, U1.11
unnamed: C2.2, U2.34 (XC1), Y1.1
unnamed: C3.2, U2.35 (XC2), Y1.2
unnamed: C4.1, L2.2, U2.30 (ANT)
unnamed: C5.1, U2.33 (DEC3)
unnamed: C6.1, U2.32 (DEC2)
unnamed: C7.1, U2.1 (DEC1)
unnamed: C8.2, U2.46 (DEC4)
unnamed: D1.2 (A), R1.1, R2.2, SW1.2 (B)
unnamed: D2.2 (A), R3.1
unnamed: R3.2, U2.9 (P0.07)

Notes on the sheet:
У платы nrf нет некоторых пинов: vdd и vss указаны только один раз Перед подключением питание к nrf должен быть Back boost converter Проверить, что mcu_pwr, mcu_btn и led подключены к правильным портам

Board: 2 copper layers, 40.0 x 40.0 mm, 25 parts (23 on the bottom side), 17 nets.

## Commit log

2020-05-18 -change icons and text, rename files -change nav view animations -replace appbar with toolbar -update styles
2020-05-18 add initial settings activity and toolbar action
2020-05-19 device fragment
2020-05-19 new resources
2020-05-19 update preferences
2020-05-19 fragment device developement
2020-05-20 fragment device extract strings and layout cleanup
2020-05-20 fragment device layout cleanup
2020-05-20 location fragment basic layout
2020-05-21 update values, new resources
2020-05-21 save navigation state
2020-05-21 replace with relative layout
2020-05-21 location activity development
2020-05-21 add location activity development
2020-05-21 new string resources
2020-05-21 remove unused strings, add translation
2020-05-21 reformat and small warning fixes
2020-05-21 update dependencies
2020-05-21 material bridge theme
2020-05-21 basic database realization
2020-05-21 new icons and command card
2020-05-21 update commands layout and icons
2020-05-21 update database prepopulated values, actions and commands fragment
2020-05-21 add locations basic realization finish
2020-05-22 make primary key autoincrement
2020-05-22 new backgrounds
2020-05-22 extract some string resources
2020-05-22 location fragment development
2020-06-06 schematics folder
2020-06-06 schematics development
2020-06-06 assigned 3d models, pcb dev
2020-06-06 pcb development
2020-06-09 location bg picker dialog
2020-06-09 new backgrounds, new icons
2020-06-10 Location bg and geoposition picker dialogs
2020-06-10 mainactivity refactor
2020-06-10 get current location BETA VERSION (only inside activity)
2020-06-17 setup gitignore
2020-06-17 google maps api, major improvements in adding location fragment
2020-06-17 add commands location, various dialogs and db update
2020-06-17 mainactivity cleanup
2020-06-17 mock methods for testing and add commands layout
2020-06-17 mainactivity and styles cleanup
2020-06-17 nrf device project setup
2020-06-18 simple device code that sends 3 button states using ble
2020-06-20 add ble dependencies
2020-06-20 move package and create service
2020-06-20 preferences update, mainactivity refactor
2020-06-21 preferences update
2020-06-21 update manifest and dependencies
2020-06-21 ble service basic realization
2020-06-22 update manifest and resources
2020-06-22 ble service scan, connect and viewmodel
2020-06-22 dialogs update: -one layout for recyclerview dialogs -bluetooth device dialog
2020-06-22 utils update
2020-06-22 -add bluetooth device dialog usage -launch service only if it wasn't -binding
2020-06-30 new manifest permissions
2020-06-30 update utils classes
2020-06-30 rename mapUtils class
2020-06-30 request permissions and check if bluetooth and locations are turned on
2020-06-30 change project packages structure
2020-06-30 remove completed todos
2020-06-30 reformat layout files and remove unnecessary comments
2020-06-30 start service when all permissions are requested
2020-06-30 service: -add location logic -refactor and move methods to utils
2020-06-30 -rename viewmodels -add getCommand method
2020-06-30 move application to folder
2020-06-30 code reformat: -optimize imports -add lambdas where possible -remove unnecessary comments -remove completed todos
2020-06-30 rearrange code
2020-06-30 service improvements: -better way to send sms from service -load actions from database
2020-07-01 internet permission
2020-07-01 add volley dependency
2020-07-01 fix server data sending
2020-07-01 smart ring server
2020-07-01 smart ring schematics
2020-07-01 fix readme
2020-07-01 add new readme server todo, fix typos
2020-08-27 add demo-video and update todo list
2020-09-13 Bump node-fetch from 2.6.0 to 2.6.1 in /server
    Bumps [node-fetch](https://github.com/bitinn/node-fetch) from 2.6.0 to 2.6.1.
    - [Release notes](https://github.com/bitinn/node-fetch/releases)
    - [Changelog](https://github.com/node-fetch/node-fetch/blob/master/docs/CHANGELOG.md)
    - [Commits](https://github.com/bitinn/node-fetch/compare/v2.6.0...v2.6.1)
2020-11-03 add antenna
2020-11-03 update schematics
2022-01-22 Bump node-fetch from 2.6.0 to 2.6.7 in /server
    Bumps [node-fetch](https://github.com/node-fetch/node-fetch) from 2.6.0 to 2.6.7.
    - [Release notes](https://github.com/node-fetch/node-fetch/releases)
    - [Changelog](https://github.com/node-fetch/node-fetch/blob/main/docs/CHANGELOG.md)
    - [Commits](https://github.com/node-fetch/node-fetch/compare/v2.6.0...v2.6.7)
    ---
    updated-dependencies:
2022-02-13 Bump ajv from 6.12.2 to 6.12.6 in /server
    Bumps [ajv](https://github.com/ajv-validator/ajv) from 6.12.2 to 6.12.6.
    - [Release notes](https://github.com/ajv-validator/ajv/releases)
    - [Commits](https://github.com/ajv-validator/ajv/compare/v6.12.2...v6.12.6)
    ---
    updated-dependencies:
    - dependency-name: ajv
2022-12-07 Bump qs from 6.5.2 to 6.5.3 in /server
    Bumps [qs](https://github.com/ljharb/qs) from 6.5.2 to 6.5.3.
    - [Release notes](https://github.com/ljharb/qs/releases)
    - [Changelog](https://github.com/ljharb/qs/blob/main/CHANGELOG.md)
    - [Commits](https://github.com/ljharb/qs/compare/v6.5.2...v6.5.3)
    ---
    updated-dependencies:
2022-12-13 Bump express from 4.17.1 to 4.17.3 in /server
    Bumps [express](https://github.com/expressjs/express) from 4.17.1 to 4.17.3.
    - [Release notes](https://github.com/expressjs/express/releases)
    - [Changelog](https://github.com/expressjs/express/blob/master/History.md)
    - [Commits](https://github.com/expressjs/express/compare/4.17.1...4.17.3)
    ---
    updated-dependencies:
